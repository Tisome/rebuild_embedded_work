# Keil uVision project Project.uvprojx, settings and files
target GD32F303RCT6_test_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_RCT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,SYS_TEST=1
  c include: ..\..\GD32F30x_Firmware_Library\CMSIS;..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\Project;..\..\freertos_code\freertos_inc;..\..\freertos_code\freertos_port;..\..\User\config;..\..\User\function_test;..\..\User\main;..\..\User\port;..\..\User\thread;..\..\User\LCD;..\..\User;..\..\LVGL\GUI\lvgl;..\..\LVGL\GUI\lvgl\examples\porting;..\..\LVGL\GUI\lvgl\src;..\..\LVGL\GUI_APP\UI_with_key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group thread
    ../../User/thread/: algorithmTask.c algorithmTask.h fakeFPGATask.c fakeFPGATask.h RUF_X_demo.c RUF_X_demo.h show_UI.c show_UI.h SPI_RxTask.c SPI_RxTask.h watchdogTask.c watchdogTask.h
  group port
    ../../User/port/: dma.c dma.h exti.c exti.h led.c led.h spi.c spi.h usart.c usart.h irq_config.h irq_config.c key.h FPGA_INT.h
  group config
    ../../User/config/: app_config.h
  group Application
    ../: gd32f30x_it.c systick.c
  group CMSIS
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Doc
    ../: readme.txt
  group Startup_HD
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Startup_XD
    ../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group User
    ../../User/main/: freertos_hook.c main.c main.h freertos_resources.h
  group freertos_src
    ../../freertos_code/freertos_src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_inc
    ../../freertos_code/freertos_inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos_port
    ../../freertos_code/freertos_port/: FreeRTOSConfig.h heap_4.c port.c portmacro.h
  group lcd
    ../../User/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h user_type.h zk.c
  group lvgl/examples/porting
    ../../LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
    ../../LVGL/GUI/lvgl/: lv_conf.h
  group lvgl/src/core
    ../../LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../../LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../../LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../../LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group lvgl/src/font
    ../../LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../../LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/hal
    ../../LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group ui
    ../../LVGL/GUI_APP/UI_with_key/: ui.c ui.h ui_events.h ui_helpers.c ui_helpers.h
    ../../LVGL/GUI_APP/UI_with_key/screens/: ui_Screen1.c ui_Screen1.h ui_Screen2.c ui_Screen2.h ui_Screen3.c ui_Screen3.h ui_Screen4.c ui_Screen4.h
    ../../LVGL/GUI_APP/UI_with_key/components/: ui_comp_hook.c
target GD32F303CGT6_Board_XD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_CGT6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD,SYS_TEST=0
  c include: ..\..\GD32F30x_Firmware_Library\CMSIS;..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\User;..\..\Project;..\..\freertos_inc;..\..\freertos_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.5.0
